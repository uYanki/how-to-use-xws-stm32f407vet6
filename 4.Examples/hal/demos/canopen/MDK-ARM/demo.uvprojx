# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Inc;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/CMSIS/Device/ST/STM32F4xx/Include;C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/CMSIS/Include;..\..\..\3rdparty\CANopenNode;..\..\..\3rdparty\CANopenNode\301;..\..\..\3rdparty\CANopenNode/303;..\..\..\3rdparty\CANopenNode/304;..\..\..\3rdparty\CANopenNode/305;..\..\..\3rdparty\CANopenNode/309;../Core/Src/cop
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/Administrator/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/CANopen
    ../../../3rdparty/CANopenNode/: CANopen.c
    ../../../3rdparty/CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
    ../../../3rdparty/CANopenNode/303/: CO_LEDs.c
    ../../../3rdparty/CANopenNode/304/: CO_GFC.c CO_SRDO.c
    ../../../3rdparty/CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
    ../../../3rdparty/CANopenNode/309/: CO_gateway_ascii.c
    ../../../3rdparty/CANopenNode/storage/: CO_storage.c CO_storageEeprom.c
    ../../../3rdparty/CANopenNode/extra/: CO_trace.c
  group Middlewares/CANopen/Port
    ../Core/Src/cop/: CO_app_STM32.c CO_driver_STM32.c CO_storageBlank.c OD.c
software components: CMSIS:CORE 5.5.0
