# Keil uVision project STM32F407VG.uvprojx, settings and files
target STM32F407VG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F407VG
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx
  c include: .\include;.\cmsis\include;.\stm32f4xx\include;.\CanOpenNode;.\CanOpenNode\stack;.\CanOpenNode\stack\STM32F4;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ./src/: fgetc.c fputc.c main.c system_stm32f4xx.c uart4.c startup_stm32f40xx.s systick.c at24c16.c i2c1.c
  group stm32f4xx
    ./stm32f4xx/src/: stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_gpio.c misc.c stm32f4xx_can.c
  group CanOpenNode
    ./CanOpenNode/: CANopen.c
    ./CanOpenNode/stack/: CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c CO_trace.c crc16-ccitt.c
    ./src/: application.c CO_OD.c
  group CanOpenNode\STM32F4
    ./CanOpenNode/stack/STM32F4/: CO_driver.c CO_main.c bxCAN.c
  group CanOpenNode\board
    ./CanOpenNode/stack/STM32F4/: CO_eeprom.c
